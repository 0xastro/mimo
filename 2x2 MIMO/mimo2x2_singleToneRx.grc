<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mimo2x2_singleToneRx</value></param>
<param><key>author</key><value>astro</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>This is a simple reciever to study mimo2x2</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>qt_qss_theme</key><value>/usr/share/gnuradio/themes/alt.qss</value></param>
<param><key>title</key><value>mimo2x2_singleToneRx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>400e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>6.283</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>channels_phase_bal</key>
<param><key>id</key><value>channels_phase_bal_0</value></param>
<param><key>alpha</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant1</key><value></value></param>
<param><key>bw1</key><value>samp_rate</value></param>
<param><key>center_freq1</key><value>freq</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>clock_rate</key><value>120e6</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source1</key><value>mimo</value></param>
<param><key>time_source1</key><value>mimo</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>channels_phase_bal_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>channels_phase_bal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
